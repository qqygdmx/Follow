# Keil uVision project Keil472_Template.uvproj, settings and files
target STM32F103RE (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Keil472_Template1 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\inc;..\Libraries\CM3;.\Systerm;..\Libraries\CM3\CoreSupport;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Libraries
    ../Libraries/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CM3/: system_stm32f10x.c startup_stm32f10x_hd.s
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group Project
    ./User/: main.c
    ./Systerm/: stm32f10x_it.c
  group Hal-Deep
    ./User/: Hal_deep.c Hal_Delay.c Hal_music.c
  group Hal_led
    ./User/: Hal-led.c
